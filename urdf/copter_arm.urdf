Commit message: Commit Ex2

File: urdf/copter_arm.urdf (robot description, URDF)
Before this commit: robot copter_arm, 3 links, 2 joints
Joints:
- joint free_joint: origin xyz=0 0 1.0 rpy=0 0 0 -> xyz=0 0 1.0 rpy=${0.5*pi} 0 0
